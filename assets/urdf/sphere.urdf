Commit message: first commit

File: assets/urdf/sphere.urdf (robot description, URDF)
Before this commit: robot object, 1 links, 0 joints
Links:
- link object: geometry collision sphere radius=0.030; visual mesh filename=sphere.obj scale=.030 .030 .030
